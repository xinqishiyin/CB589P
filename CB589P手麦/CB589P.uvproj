# Keil uVision project CB589P.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC51F2832 silan
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0x7FFF) CLOCK(2000000) MODP2
  output: CB589P
  c flags: Optimize=6 SizeSpeed=1
  c include: G:\CB589P
  group Source Group 1
    ./: main.c system.c TM1722.c Keys.c KB4815.c Menu.c at24c08.c memory.c handler.c uart.c lcd.c CB_Line.c MenuEvent.c
